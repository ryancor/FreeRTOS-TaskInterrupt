# Keil uVision project FreeRTOS-Queues-from_Interrupt.uvprojx, settings and files
target FreeRTOS-Queues (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FreeRTOS-Queues-from_Interrupt +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\FreeRTOS-Source\include;..\FreeRTOS-Source\portable\RVDS\ARM_CM4F;..\FreeRTOS-Queues-from_Interrupt
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./: main.c
  group FreeRTOS
    ../FreeRTOS-Source/: list.c queue.c tasks.c timers.c
    ../FreeRTOS-Source/portable/MemMang/: heap_2.c
    ../FreeRTOS-Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 5.0.1, Compiler:I/O:STDOUT 1.2.0, Device:STM32Cube Framework:Classic 1.6.0, Device:STM32Cube HAL:Common 1.6.0, Device:STM32Cube HAL:Cortex 1.6.0, Device:STM32Cube HAL:GPIO 1.6.0, Device:STM32Cube HAL:PWR 1.6.0, Device:STM32Cube HAL:RCC 1.6.0, Device:Startup 2.6.0
